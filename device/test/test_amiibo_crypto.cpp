// Host-native tests for amiibo_crypto.h: the TagMo-equivalent re-signing
// pipeline (key files -> unpack -> UID patch -> pack -> PWD/PACK).
//
// The crypto backends used here are small reference implementations
// (AES-128-CTR and HMAC-SHA256) written for this test only. They are
// self-checked against FIPS-197, FIPS-180-4 and RFC 4231 vectors, so the
// amiitool cross-check fixtures below validate the *algorithm* against an
// independent implementation.
//
// The KEYS/PLAIN/TAG/TAG_RESIGNED fixtures were produced by running the real
// socram8888/amiitool (MIT) with random key files and a synthetic image, so
// they contain no Nintendo proprietary data.
//
// Build & run:
//   g++ -std=c++11 -Wall -Wextra -pedantic -I ../src test_amiibo_crypto.cpp && ./a.out
#include "amiibo_crypto.h"

#include <cstdio>
#include <cstring>

static int failures = 0;
static int checks = 0;

#define CHECK(cond)                                                            \
  do {                                                                         \
    checks++;                                                                  \
    if (!(cond)) {                                                             \
      failures++;                                                              \
      std::printf("FAIL %s:%d: %s\n", __FILE__, __LINE__, #cond);              \
    }                                                                          \
  } while (0)

#define CHECK_EQ(a, b)                                                         \
  do {                                                                         \
    checks++;                                                                  \
    if (!((a) == (b))) {                                                       \
      failures++;                                                              \
      std::printf("FAIL %s:%d: %s == %s\n", __FILE__, __LINE__, #a, #b);       \
    }                                                                          \
  } while (0)

// ---------------------------------------------------------------------------
// Reference crypto backends (test-only).
// ---------------------------------------------------------------------------
#include <stdint.h>
#include <stddef.h>

// Reference tables, generated and verified against FIPS-197 / FIPS-180-4.
static const uint8_t AES_SBOX[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16,
};
static const uint32_t SHA256_H[8] = {0x6a09e667u,0xbb67ae85u,0x3c6ef372u,0xa54ff53au,0x510e527fu,0x9b05688cu,0x1f83d9abu,0x5be0cd19u};
static const uint32_t SHA256_K[64] = {
    0x428a2f98u,0x71374491u,0xb5c0fbcfu,0xe9b5dba5u,0x3956c25bu,0x59f111f1u,0x923f82a4u,0xab1c5ed5u,
    0xd807aa98u,0x12835b01u,0x243185beu,0x550c7dc3u,0x72be5d74u,0x80deb1feu,0x9bdc06a7u,0xc19bf174u,
    0xe49b69c1u,0xefbe4786u,0x0fc19dc6u,0x240ca1ccu,0x2de92c6fu,0x4a7484aau,0x5cb0a9dcu,0x76f988dau,
    0x983e5152u,0xa831c66du,0xb00327c8u,0xbf597fc7u,0xc6e00bf3u,0xd5a79147u,0x06ca6351u,0x14292967u,
    0x27b70a85u,0x2e1b2138u,0x4d2c6dfcu,0x53380d13u,0x650a7354u,0x766a0abbu,0x81c2c92eu,0x92722c85u,
    0xa2bfe8a1u,0xa81a664bu,0xc24b8b70u,0xc76c51a3u,0xd192e819u,0xd6990624u,0xf40e3585u,0x106aa070u,
    0x19a4c116u,0x1e376c08u,0x2748774cu,0x34b0bcb5u,0x391c0cb3u,0x4ed8aa4au,0x5b9cca4fu,0x682e6ff3u,
    0x748f82eeu,0x78a5636fu,0x84c87814u,0x8cc70208u,0x90befffau,0xa4506cebu,0xbef9a3f7u,0xc67178f2u,
};

// ---- AES-128 (encrypt only, CTR needs no decryption) ----

static void aes128ExpandKey(const uint8_t* key, uint8_t roundKeys[176]) {
  memcpy(roundKeys, key, 16);
  uint8_t rcon = 0x01;
  for (size_t i = 16; i < 176; i += 4) {
    uint8_t t[4];
    memcpy(t, roundKeys + i - 4, 4);
    if (i % 16 == 0) {
      uint8_t first = t[0];
      t[0] = AES_SBOX[t[1]] ^ rcon;
      t[1] = AES_SBOX[t[2]];
      t[2] = AES_SBOX[t[3]];
      t[3] = AES_SBOX[first];
      rcon = (uint8_t)((rcon << 1) ^ ((rcon & 0x80) ? 0x1B : 0));
    }
    for (int j = 0; j < 4; j++) roundKeys[i + j] = roundKeys[i - 16 + j] ^ t[j];
  }
}

static uint8_t gmul(uint8_t a, uint8_t b) {
  uint8_t p = 0;
  for (int i = 0; i < 8; i++) {
    if (b & 1) p ^= a;
    uint8_t hi = a & 0x80;
    a = (uint8_t)(a << 1);
    if (hi) a ^= 0x1B;
    b >>= 1;
  }
  return p;
}

static void aes128EncryptBlock(const uint8_t roundKeys[176], const uint8_t in[16],
                               uint8_t out[16]) {
  uint8_t s[16];
  memcpy(s, in, 16);
  for (int i = 0; i < 16; i++) s[i] ^= roundKeys[i];
  for (int round = 1; round <= 10; round++) {
    for (int i = 0; i < 16; i++) s[i] = AES_SBOX[s[i]];
    // ShiftRows on the column-major state: row r (i%4) rotates left by r.
    uint8_t t[16];
    for (int c = 0; c < 4; c++)
      for (int r = 0; r < 4; r++) t[c * 4 + r] = s[((c + r) % 4) * 4 + r];
    memcpy(s, t, 16);
    if (round != 10) {
      for (int c = 0; c < 4; c++) {
        uint8_t a0 = s[c*4], a1 = s[c*4+1], a2 = s[c*4+2], a3 = s[c*4+3];
        s[c*4+0] = gmul(a0, 2) ^ gmul(a1, 3) ^ a2 ^ a3;
        s[c*4+1] = a0 ^ gmul(a1, 2) ^ gmul(a2, 3) ^ a3;
        s[c*4+2] = a0 ^ a1 ^ gmul(a2, 2) ^ gmul(a3, 3);
        s[c*4+3] = gmul(a0, 3) ^ a1 ^ a2 ^ gmul(a3, 2);
      }
    }
    for (int i = 0; i < 16; i++) s[i] ^= roundKeys[round * 16 + i];
  }
  memcpy(out, s, 16);
}

extern "C" void otAes128CtrXor(const uint8_t* key, const uint8_t* iv,
                               uint8_t* data, size_t len) {
  uint8_t rk[176], ctr[16], ks[16];
  aes128ExpandKey(key, rk);
  memcpy(ctr, iv, 16);
  size_t off = 0;
  while (off < len) {
    aes128EncryptBlock(rk, ctr, ks);
    size_t n = (len - off < 16) ? len - off : 16;
    for (size_t i = 0; i < n; i++) data[off + i] ^= ks[i];
    off += n;
    for (int i = 15; i >= 0; i--) {  // 128-bit big-endian increment
      if (++ctr[i] != 0) break;
    }
  }
}

// ---- SHA-256 + HMAC ----

struct Sha256Ctx {
  uint32_t h[8];
  uint64_t total;
  uint8_t buf[64];
  size_t bufLen;
};

static uint32_t rotr32(uint32_t x, int n) { return (x >> n) | (x << (32 - n)); }

static void sha256Compress(uint32_t h[8], const uint8_t block[64]) {
  uint32_t w[64];
  for (int i = 0; i < 16; i++)
    w[i] = ((uint32_t)block[i*4] << 24) | ((uint32_t)block[i*4+1] << 16) |
           ((uint32_t)block[i*4+2] << 8) | (uint32_t)block[i*4+3];
  for (int i = 16; i < 64; i++) {
    uint32_t s0 = rotr32(w[i-15], 7) ^ rotr32(w[i-15], 18) ^ (w[i-15] >> 3);
    uint32_t s1 = rotr32(w[i-2], 17) ^ rotr32(w[i-2], 19) ^ (w[i-2] >> 10);
    w[i] = w[i-16] + s0 + w[i-7] + s1;
  }
  uint32_t a = h[0], b = h[1], c = h[2], d = h[3];
  uint32_t e = h[4], f = h[5], g = h[6], hh = h[7];
  for (int i = 0; i < 64; i++) {
    uint32_t S1 = rotr32(e, 6) ^ rotr32(e, 11) ^ rotr32(e, 25);
    uint32_t ch = (e & f) ^ (~e & g);
    uint32_t t1 = hh + S1 + ch + SHA256_K[i] + w[i];
    uint32_t S0 = rotr32(a, 2) ^ rotr32(a, 13) ^ rotr32(a, 22);
    uint32_t maj = (a & b) ^ (a & c) ^ (b & c);
    uint32_t t2 = S0 + maj;
    hh = g; g = f; f = e; e = d + t1;
    d = c; c = b; b = a; a = t1 + t2;
  }
  h[0] += a; h[1] += b; h[2] += c; h[3] += d;
  h[4] += e; h[5] += f; h[6] += g; h[7] += hh;
}

static void sha256Init(Sha256Ctx* ctx) {
  memcpy(ctx->h, SHA256_H, sizeof(ctx->h));
  ctx->total = 0;
  ctx->bufLen = 0;
}

static void sha256Update(Sha256Ctx* ctx, const uint8_t* data, size_t len) {
  ctx->total += len;
  while (len > 0) {
    size_t n = 64 - ctx->bufLen;
    if (n > len) n = len;
    memcpy(ctx->buf + ctx->bufLen, data, n);
    ctx->bufLen += n;
    data += n;
    len -= n;
    if (ctx->bufLen == 64) {
      sha256Compress(ctx->h, ctx->buf);
      ctx->bufLen = 0;
    }
  }
}

static void sha256Final(Sha256Ctx* ctx, uint8_t out[32]) {
  uint64_t bits = ctx->total * 8;
  uint8_t pad = 0x80;
  sha256Update(ctx, &pad, 1);
  uint8_t zero = 0;
  while (ctx->bufLen != 56) sha256Update(ctx, &zero, 1);
  uint8_t lenBe[8];
  for (int i = 0; i < 8; i++) lenBe[i] = (uint8_t)(bits >> (56 - 8 * i));
  sha256Update(ctx, lenBe, 8);
  for (int i = 0; i < 8; i++) {
    out[i*4+0] = (uint8_t)(ctx->h[i] >> 24);
    out[i*4+1] = (uint8_t)(ctx->h[i] >> 16);
    out[i*4+2] = (uint8_t)(ctx->h[i] >> 8);
    out[i*4+3] = (uint8_t)(ctx->h[i]);
  }
}

static void sha256(const uint8_t* data, size_t len, uint8_t out[32]) {
  Sha256Ctx ctx;
  sha256Init(&ctx);
  sha256Update(&ctx, data, len);
  sha256Final(&ctx, out);
}

extern "C" void otHmacSha256(const uint8_t* key, size_t keyLen,
                             const uint8_t* data, size_t len, uint8_t* out32) {
  uint8_t k[64] = {0};
  if (keyLen > 64) {
    sha256(key, keyLen, k);
  } else {
    memcpy(k, key, keyLen);
  }
  uint8_t ipad[64], opad[64];
  for (int i = 0; i < 64; i++) {
    ipad[i] = k[i] ^ 0x36;
    opad[i] = k[i] ^ 0x5C;
  }
  uint8_t inner[32];
  Sha256Ctx ctx;
  sha256Init(&ctx);
  sha256Update(&ctx, ipad, 64);
  sha256Update(&ctx, data, len);
  sha256Final(&ctx, inner);
  sha256Init(&ctx);
  sha256Update(&ctx, opad, 64);
  sha256Update(&ctx, inner, 32);
  sha256Final(&ctx, out32);
}

// ---------------------------------------------------------------------------
// Fixtures: generated by the real amiitool (random keys, synthetic image).
// ---------------------------------------------------------------------------

static const uint8_t REF_KEYS[160] = {
    0x46,0x64,0x31,0x29,0x64,0x86,0xed,0x9c,0xd7,0x1f,0xc2,0x07,0x25,0x48,0x20,0xa2,
    0x75,0x6e,0x66,0x69,0x78,0x65,0x64,0x20,0x69,0x6e,0x66,0x6f,0x73,0x00,0xf1,0x10,
    0x94,0x22,0x3c,0xf8,0xa8,0x29,0x95,0x80,0x49,0x57,0x87,0x6e,0x9f,0xa7,0x11,0x63,
    0x50,0x6b,0x4e,0x5b,0x8c,0x8f,0xa4,0xdb,0x1b,0x95,0xd3,0xe8,0xc5,0xc5,0xfb,0x5a,
    0xe7,0x37,0x52,0x90,0x60,0xe7,0x10,0xa9,0x3e,0x97,0x18,0xdd,0x3e,0x29,0x41,0x8e,
    0x94,0x8f,0xe9,0x20,0x1f,0x8d,0xfb,0x3a,0x22,0xcf,0x22,0xe8,0x94,0x1d,0x42,0x7b,
    0x6c,0x6f,0x63,0x6b,0x65,0x64,0x20,0x73,0x65,0x63,0x72,0x65,0x74,0x00,0x7f,0x10,
    0x68,0x69,0x54,0x87,0xf6,0x4f,0xc1,0x19,0x1e,0xe3,0x01,0xb2,0x00,0x43,0x2e,0x54,
    0xd7,0x39,0x09,0x53,0x55,0x67,0x0e,0x07,0xdd,0xa6,0xf8,0x7c,0x7f,0x78,0xaf,0xe7,
    0xe1,0x03,0x6f,0xd7,0x53,0x30,0xf0,0x71,0x14,0xf1,0x24,0x14,0x34,0x52,0x69,0x0c,
};
static const uint8_t REF_PLAIN[520] = {
    0x8b,0x72,0x5f,0xe0,0xd9,0x6d,0xe8,0xb6,0x13,0xe0,0x32,0x92,0x58,0xe1,0x7a,0x39,
    0xe5,0xe9,0x11,0x38,0x19,0x01,0xa9,0x2d,0xf3,0xcd,0x42,0x27,0x1f,0xab,0x33,0xab,
    0x1d,0x93,0x8b,0xf6,0x00,0x73,0xac,0x14,0x54,0xde,0xa6,0xac,0xbf,0x20,0xe6,0xa4,
    0x09,0xf7,0xdc,0x23,0xf8,0x86,0x50,0xeb,0x53,0x92,0x13,0x73,0x3d,0x46,0x1e,0x5a,
    0xd9,0xa9,0x50,0xda,0x1d,0xfc,0xee,0x71,0xda,0x94,0x1d,0x9a,0xb5,0x03,0x3e,0xbe,
    0xfa,0x1b,0xe1,0xf3,0xa1,0x32,0xde,0xf4,0xc4,0xf1,0x67,0x02,0x38,0x85,0x5c,0x11,
    0x2f,0xad,0xeb,0x4c,0xa9,0xd9,0xbd,0x84,0x6e,0xda,0x1e,0x23,0xde,0x5c,0xe1,0xd8,
    0x77,0xc3,0xcb,0x18,0xf5,0xaa,0x0d,0xb9,0x9b,0x74,0xbb,0xd3,0xfa,0x18,0xe5,0x29,
    0xc5,0xd0,0x75,0x6e,0xaa,0x32,0xf2,0x18,0x0c,0x10,0x3b,0xea,0x6d,0x1c,0xc3,0xe4,
    0xdf,0x8e,0xfd,0xd4,0x38,0x0a,0x8e,0xd4,0x7e,0x49,0xa7,0x78,0x61,0x8c,0xa1,0x26,
    0x5d,0x16,0x95,0x07,0x48,0x87,0x1f,0x55,0x98,0x5a,0x3f,0x05,0x76,0x02,0xe9,0x56,
    0x91,0xe6,0x2a,0xc9,0xf0,0xb8,0x9d,0x6f,0x02,0x45,0xe7,0x63,0xd1,0x89,0x8a,0x2e,
    0x9f,0x1f,0x35,0xe8,0xa6,0x54,0x3d,0x3e,0xae,0x7c,0x43,0x25,0x7f,0x2d,0x7b,0x10,
    0x13,0xa5,0xd9,0x04,0x5e,0x77,0x73,0x60,0xbc,0x5a,0xc3,0x8d,0xe3,0x4d,0xbc,0x83,
    0x6c,0xf1,0x6b,0x13,0x46,0xa8,0x51,0xf4,0x24,0x95,0x19,0xa3,0xc2,0x94,0xb3,0xd5,
    0x3a,0x8d,0xd9,0x98,0x04,0x4c,0xf8,0xc0,0xa7,0xbb,0x4d,0x8a,0x09,0x09,0x0d,0x75,
    0xfb,0x78,0x88,0x41,0x20,0xda,0x35,0x45,0x6f,0x4f,0xe8,0x31,0xe3,0x9c,0x06,0x1d,
    0x29,0xe0,0xb5,0x2d,0x2c,0xad,0xed,0xd3,0x69,0x3a,0x5e,0x72,0x44,0x6b,0xe7,0x3f,
    0xe4,0x70,0x80,0x04,0x4a,0xb5,0x49,0xb9,0x04,0x32,0xea,0xe8,0xce,0xf0,0x05,0xf7,
    0xd0,0xbb,0x24,0xfd,0x68,0x11,0xd0,0xd1,0x4b,0x2e,0x43,0x8f,0x9a,0x2b,0xce,0x7e,
    0x9b,0x4e,0x82,0xe5,0x04,0xcc,0x9e,0x08,0xfe,0x88,0xf0,0xcc,0x78,0xf6,0xc3,0x49,
    0xb1,0xe7,0x46,0x19,0xf8,0x16,0xeb,0x43,0x45,0x2e,0xd3,0xdf,0x59,0xa1,0x5d,0xf4,
    0xf0,0xdf,0xd9,0xf4,0xab,0x77,0xfc,0xa9,0xff,0xed,0x75,0x78,0xe3,0x38,0xc1,0x94,
    0x1f,0x07,0xad,0x17,0x1d,0x98,0x5b,0x62,0xc7,0x2e,0x41,0x20,0xcf,0x9e,0x15,0xbf,
    0x7e,0xee,0xb3,0x29,0x66,0xb0,0xd3,0x65,0x9d,0x48,0xdd,0x80,0x81,0x9e,0x14,0xa0,
    0xa5,0xc1,0xb8,0xc3,0x5a,0x13,0x25,0x21,0x41,0x67,0x41,0x10,0x05,0x56,0xd0,0x83,
    0x45,0x83,0xad,0xab,0x33,0x80,0x10,0xd0,0xc8,0xee,0x50,0x49,0x8c,0x64,0xea,0x32,
    0x26,0xa2,0xf5,0x80,0xb5,0x1a,0xa1,0xf6,0x81,0xe2,0x06,0x87,0x39,0xd6,0x0a,0x7e,
    0x5a,0xb7,0x29,0x8d,0x37,0x39,0x5e,0x00,0x27,0xae,0x49,0xb4,0x13,0x33,0xe6,0x39,
    0xd5,0xdb,0xb9,0x8a,0x04,0x11,0x22,0xbf,0x33,0x44,0x55,0x66,0x44,0x08,0xf3,0xb7,
    0xc0,0x1c,0x45,0xf7,0x56,0xa3,0xf7,0x7d,0x51,0x41,0x31,0x64,0x74,0x17,0x9d,0x4a,
    0xf2,0x56,0xd4,0xe8,0xb0,0x55,0x5f,0xed,0xdc,0x5d,0x62,0x39,0x65,0x56,0xf1,0x25,
    0x72,0x36,0x1d,0xc8,0xd9,0x14,0x46,0x2a,
};
static const uint8_t REF_TAG[540] = {
    0x04,0x11,0x22,0xbf,0x33,0x44,0x55,0x66,0x8b,0x72,0x5f,0xe0,0xd9,0x6d,0xe8,0xb6,
    0x54,0xde,0xa6,0xac,0x49,0x29,0x79,0x1d,0x74,0xc4,0x11,0x15,0xaa,0x4d,0x19,0xd7,
    0x3a,0xc7,0x8a,0xbb,0xe3,0xb6,0x14,0xac,0x05,0x83,0xbb,0x06,0x6d,0xc7,0x2b,0xbe,
    0x0a,0xd7,0xce,0xc3,0x52,0x24,0x09,0xe2,0xb8,0x4d,0x6a,0x23,0x2f,0x01,0x77,0x09,
    0x16,0x9a,0x71,0xcb,0x21,0x34,0xfb,0xae,0x89,0xd0,0x45,0xcc,0xbb,0xb1,0xd2,0x89,
    0x78,0x24,0x46,0xd1,0x44,0x08,0xf3,0xb7,0xc0,0x1c,0x45,0xf7,0x56,0xa3,0xf7,0x7d,
    0x51,0x41,0x31,0x64,0x74,0x17,0x9d,0x4a,0xf2,0x56,0xd4,0xe8,0xb0,0x55,0x5f,0xed,
    0xdc,0x5d,0x62,0x39,0x65,0x56,0xf1,0x25,0x72,0x36,0x1d,0xc8,0xd9,0x14,0x46,0x2a,
    0x17,0xa0,0xe7,0x7c,0x2e,0x14,0xfe,0x12,0xd0,0x9e,0x39,0x88,0x2f,0x10,0xdf,0x68,
    0x22,0x93,0x84,0xd3,0x0c,0x9a,0x4c,0xc8,0x15,0x9d,0x98,0x2a,0x5c,0x7e,0x0c,0xb3,
    0x78,0x28,0x62,0x4c,0x30,0x20,0x49,0xd3,0x9f,0x9f,0x0e,0x8c,0xc4,0x09,0x9a,0x53,
    0x37,0x9b,0xbd,0xce,0x4f,0xc8,0x35,0xf8,0x91,0x8b,0x95,0x66,0xd9,0xfa,0xc3,0x5f,
    0xf9,0xc8,0x0b,0x30,0x48,0x7e,0x59,0x7d,0xf6,0x12,0xd5,0xf3,0xb7,0x73,0xa9,0x01,
    0x08,0x52,0x82,0xcf,0xe8,0x62,0x24,0x3b,0x78,0x24,0xf2,0x51,0x54,0x0c,0x8e,0x2f,
    0xdf,0xd6,0x07,0x5d,0x04,0xbd,0x21,0x3c,0xab,0xd5,0xea,0x89,0x9c,0x2d,0x88,0x17,
    0x51,0x5e,0x53,0x40,0x04,0x8a,0xaf,0x27,0xed,0xef,0x6b,0x94,0xb9,0x05,0x68,0x6c,
    0xa7,0x37,0x7a,0x7d,0x4d,0x66,0x63,0xb0,0xf3,0x6b,0xfd,0xfd,0xdf,0x3e,0x7a,0x45,
    0xa0,0xb8,0xcf,0x31,0x53,0x72,0x39,0x36,0x18,0xa6,0xfd,0xf1,0xd9,0xe0,0x65,0xe2,
    0xc2,0xcd,0x59,0xd8,0x3b,0x90,0xe8,0x07,0x2a,0x52,0xc4,0x8d,0x71,0xcb,0x95,0x4f,
    0x96,0x1f,0x76,0xe2,0x3c,0x20,0x76,0x0c,0xd9,0x9c,0xb0,0x35,0x84,0x7a,0x88,0x0b,
    0xda,0xbc,0x5b,0x5f,0x18,0xc3,0x60,0x38,0x3f,0x51,0xda,0x4f,0x9c,0x2b,0x6a,0xde,
    0x2d,0x79,0xdd,0x23,0x80,0x34,0xcb,0xfa,0x85,0x65,0x8a,0x8a,0xb0,0x46,0x0e,0x20,
    0xcc,0x11,0xc6,0x33,0xff,0x00,0x7d,0x34,0x6e,0x5d,0x32,0xa7,0x5c,0xb5,0x2c,0x85,
    0x66,0x14,0x74,0xa6,0xbd,0xc4,0xc4,0x2a,0xd7,0xba,0xf1,0x0b,0x44,0xb9,0x32,0x17,
    0x1d,0xc3,0xf2,0x14,0x06,0x0e,0x27,0xe9,0x7b,0xfd,0x17,0x97,0x7b,0xf4,0xcc,0xd9,
    0x33,0x16,0x96,0x40,0xfe,0xe7,0x02,0xd6,0xe1,0x2c,0x88,0x34,0x41,0xe1,0x76,0x71,
    0xae,0xb0,0x10,0x3a,0xf6,0x9e,0x5e,0x9e,0x1f,0xea,0xc4,0x33,0xe1,0x4a,0x2b,0x80,
    0xc3,0x40,0x75,0x71,0xa7,0xb2,0x0a,0x19,0xa5,0xb0,0xa6,0xf5,0x6f,0x51,0x6d,0x29,
    0xb9,0x93,0x01,0x6e,0xf6,0xb9,0x17,0x7d,0x00,0x5e,0xa5,0x05,0xab,0x9a,0x13,0x2c,
    0x29,0xf1,0xe2,0x83,0x03,0x65,0x25,0xda,0x5c,0xe1,0xcd,0xe0,0xc6,0xf3,0x30,0xa1,
    0xb4,0xc6,0xbc,0xac,0x51,0x86,0x50,0xa0,0x1b,0x46,0x71,0x82,0xb1,0x6d,0x20,0x5c,
    0x5a,0x98,0x03,0xcc,0xf5,0x0c,0x72,0xde,0x9b,0xbd,0xb3,0x71,0x4f,0x29,0x7a,0x6c,
    0x35,0x2e,0xde,0x8c,0x3a,0xae,0x0e,0xfe,0x01,0x00,0x0f,0x00,0x00,0x00,0x00,0x04,
    0x5f,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
static const uint8_t REF_TAG_RESIGNED[540] = {
    0x04,0xc0,0x0a,0x46,0x46,0x61,0x6b,0x65,0x8b,0x72,0x5f,0xe0,0xd9,0x6d,0xe8,0xb6,
    0x54,0xde,0xa6,0xac,0xe8,0xc5,0x20,0x69,0x16,0xee,0x17,0x9e,0xe0,0xeb,0x87,0x18,
    0x15,0xb5,0x61,0xe9,0x2d,0xe7,0x4e,0x05,0xbc,0x48,0xe1,0xc3,0x45,0x68,0x82,0x2b,
    0xc8,0xce,0x51,0xe5,0x10,0xeb,0xc0,0xd1,0xb8,0x10,0x91,0xe8,0xec,0x62,0x8c,0x97,
    0xef,0x08,0x6d,0x7c,0xe4,0x32,0xed,0x95,0xfd,0xa0,0x70,0xa1,0xfa,0xd1,0xea,0xdb,
    0x35,0x48,0xaa,0x4e,0x29,0x08,0xf3,0xb7,0xc0,0x1c,0x45,0xf7,0x56,0xa3,0xf7,0x7d,
    0x51,0x41,0x31,0x64,0x74,0x17,0x9d,0x4a,0xf2,0x56,0xd4,0xe8,0xb0,0x55,0x5f,0xed,
    0xdc,0x5d,0x62,0x39,0x65,0x56,0xf1,0x25,0x72,0x36,0x1d,0xc8,0xd9,0x14,0x46,0x2a,
    0xcd,0x52,0x68,0x80,0x09,0xa0,0xaf,0x1b,0x6b,0x92,0x52,0x55,0x08,0x73,0xfa,0xe7,
    0x54,0x47,0x77,0x90,0x42,0x14,0xbf,0x0a,0x28,0x31,0x59,0xec,0x84,0xef,0xc6,0x62,
    0xb2,0x5b,0x02,0xd2,0x3c,0x31,0xfa,0x40,0x53,0x93,0x81,0x59,0xa5,0xdd,0xdc,0xea,
    0x94,0xba,0x72,0xe7,0x60,0xb5,0xd9,0xa8,0x68,0x4c,0x69,0x57,0x27,0x50,0x27,0xa8,
    0x82,0x70,0xa8,0x88,0x82,0x7b,0x33,0x7b,0x23,0x12,0x2d,0xfe,0xc6,0x83,0x60,0xb5,
    0x0c,0x05,0x3d,0xd0,0x32,0x3b,0x21,0x8c,0x9a,0xf2,0xfe,0x4a,0x0c,0x9d,0xff,0x99,
    0x13,0x96,0xbc,0x3c,0x19,0x9a,0x66,0x5f,0x32,0x5d,0xbd,0xb7,0x62,0xa3,0x76,0x18,
    0x4f,0x61,0xad,0xc2,0xf5,0xaa,0x6c,0x96,0xf7,0xbd,0x2e,0xd4,0x3d,0xd6,0x3f,0x50,
    0x83,0x04,0xa0,0x9c,0xd8,0x1f,0xae,0xe9,0x2c,0x64,0x22,0x8b,0x24,0xd1,0x3c,0xc5,
    0x2d,0xf5,0xbf,0xb2,0xc4,0xf8,0x40,0x64,0x6a,0xdc,0x1f,0x54,0xba,0xf0,0xf0,0x83,
    0x24,0x6c,0x0e,0xd5,0x57,0x9c,0x93,0x91,0x04,0xdb,0x2b,0xaf,0x52,0xab,0x22,0x03,
    0xc9,0x54,0xce,0xd0,0x2b,0x00,0x1c,0xd7,0x57,0x03,0x5d,0x82,0x69,0x4c,0x6b,0x44,
    0xd2,0x96,0xdc,0x6d,0x0a,0xc8,0x3c,0x9e,0x98,0xb3,0x48,0xc9,0x49,0x5d,0x4a,0xc9,
    0xee,0xbf,0x48,0xc3,0xb7,0x39,0xb7,0xaa,0xe2,0x45,0x27,0x67,0xe1,0x52,0x71,0x69,
    0x42,0x41,0x7b,0x4d,0xa7,0x96,0xfa,0x08,0xd4,0xb9,0x74,0x34,0x29,0x6a,0xe4,0x0e,
    0x5c,0x3c,0x12,0xdd,0xa4,0x9a,0x5a,0x94,0xbf,0xa6,0x5a,0xf5,0xba,0x00,0x8c,0xf0,
    0x3a,0xe9,0x9b,0x4c,0x7e,0xb4,0xfc,0x4f,0xc3,0xa6,0x42,0x55,0xb7,0x6c,0x1f,0xc5,
    0x9a,0xdc,0x99,0xcc,0xa3,0x74,0x77,0xc3,0xf7,0x26,0x18,0xbb,0x09,0x30,0xee,0xbc,
    0x27,0xf1,0xfd,0xf3,0xec,0x57,0x4c,0x05,0x51,0x22,0x27,0x3c,0x26,0x21,0x10,0x06,
    0xc0,0x21,0x3c,0x85,0x70,0x54,0xf4,0x07,0x91,0x95,0x3d,0x4f,0x1f,0xe4,0x89,0xd2,
    0x33,0xdb,0x50,0xa1,0xb5,0x90,0x53,0x1e,0xfd,0xd6,0xbd,0xf5,0x41,0xf1,0x48,0x2a,
    0x2d,0xb9,0x93,0x3d,0xa2,0x5d,0x22,0x33,0xd8,0x44,0x4d,0x7e,0xb4,0x63,0xa1,0x1f,
    0x45,0x42,0xa1,0x70,0x77,0x9a,0x36,0x16,0x59,0x0d,0x0b,0x3c,0x30,0x6e,0x42,0x85,
    0xfa,0x39,0xc8,0x78,0xf2,0xa5,0xcf,0xec,0x4b,0x59,0x8e,0x92,0x0a,0xeb,0xc4,0x44,
    0xa2,0xf0,0x8c,0x5f,0xd8,0x59,0x6d,0x85,0x01,0x00,0x0f,0x00,0x00,0x00,0x00,0x04,
    0x5f,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
static const uint8_t TAG_RESIGNED_IDPAGES[9] = {
    0x04,0xc0,0x0a,0x46,0x46,0x61,0x6b,0x65,0x8b,
};
static const uint8_t EXPECTED_PWD[4] = {
    0x2c,0x3e,0x87,0x51,
};
static const uint8_t KEY_FIPS197[16] = {
    0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f,
};
static const uint8_t PT_FIPS197[16] = {
    0x00,0x11,0x22,0x33,0x44,0x55,0x66,0x77,0x88,0x99,0xaa,0xbb,0xcc,0xdd,0xee,0xff,
};
static const uint8_t CT_FIPS197[16] = {
    0x69,0xc4,0xe0,0xd8,0x6a,0x7b,0x04,0x30,0xd8,0xcd,0xb7,0x80,0x70,0xb4,0xc5,0x5a,
};
static const uint8_t SHA_ABC[32] = {
    0xba,0x78,0x16,0xbf,0x8f,0x01,0xcf,0xea,0x41,0x41,0x40,0xde,0x5d,0xae,0x22,0x23,
    0xb0,0x03,0x61,0xa3,0x96,0x17,0x7a,0x9c,0xb4,0x10,0xff,0x61,0xf2,0x00,0x15,0xad,
};
static const uint8_t HMAC_RFC1[32] = {
    0xb0,0x34,0x4c,0x61,0xd8,0xdb,0x38,0x53,0x5c,0xa8,0xaf,0xce,0xaf,0x0b,0xf1,0x2b,
    0x88,0x1d,0xc2,0x00,0xc9,0x83,0x3d,0xa7,0x26,0xe9,0x37,0x6c,0x2e,0x32,0xcf,0xf7,
};
static const uint8_t HMAC_RFC2[32] = {
    0x5b,0xdc,0xc1,0x46,0xbf,0x60,0x75,0x4e,0x6a,0x04,0x24,0x26,0x08,0x95,0x75,0xc7,
    0x5a,0x00,0x3f,0x08,0x9d,0x27,0x39,0x83,0x9d,0xec,0x58,0xb9,0x64,0xec,0x38,0x43,
};

// ---------------------------------------------------------------------------
// Tests
// ---------------------------------------------------------------------------

using namespace amiibo;

static void testCryptoBackends() {
  // FIPS-197 appendix C.1
  uint8_t rk[176];
  aes128ExpandKey(KEY_FIPS197, rk);
  uint8_t ct[16];
  aes128EncryptBlock(rk, PT_FIPS197, ct);
  CHECK(memcmp(ct, CT_FIPS197, 16) == 0);

  // CTR keystream sanity: iv=0, len=16 -> ct = pt ^ AES_E(0)
  uint8_t zeroIv[16] = {0};
  uint8_t buf[16];
  memcpy(buf, PT_FIPS197, 16);
  uint8_t e0[16];
  aes128ExpandKey(KEY_FIPS197, rk);
  memset(e0, 0, 16);
  aes128EncryptBlock(rk, e0, e0);
  otAes128CtrXor(KEY_FIPS197, zeroIv, buf, 16);
  for (int i = 0; i < 16; i++) CHECK_EQ(buf[i], (uint8_t)(PT_FIPS197[i] ^ e0[i]));

  // FIPS-180-4: SHA-256("abc")
  uint8_t d[32];
  sha256((const uint8_t*)"abc", 3, d);
  CHECK(memcmp(d, SHA_ABC, 32) == 0);

  // RFC 4231 test cases 1 and 2
  uint8_t k1[20];
  memset(k1, 0x0b, sizeof(k1));
  otHmacSha256(k1, sizeof(k1), (const uint8_t*)"Hi There", 8, d);
  CHECK(memcmp(d, HMAC_RFC1, 32) == 0);
  otHmacSha256((const uint8_t*)"Jefe", 4,
               (const uint8_t*)"what do ya want for nothing?", 28, d);
  CHECK(memcmp(d, HMAC_RFC2, 32) == 0);

  // Counter increment across block boundary: encrypt 32 bytes, check that
  // the second block used counter 1.
  uint8_t iv[16] = {0};
  uint8_t a[32] = {0}, b[32] = {0};
  otAes128CtrXor(KEY_FIPS197, iv, a, 32);
  uint8_t iv1[16] = {0};
  iv1[15] = 1;
  otAes128CtrXor(KEY_FIPS197, iv1, b + 16, 16);
  CHECK(memcmp(a + 16, b + 16, 16) == 0);
}

static void testKeyFileHandling() {
  AmiiboKeys keys;
  CHECK(identifyKeyFile(REF_KEYS, 80) == KEY_DATA);
  CHECK(identifyKeyFile(REF_KEYS + 80, 80) == KEY_TAG);
  CHECK(identifyKeyFile(REF_KEYS, 79) == KEY_UNKNOWN);
  CHECK(identifyKeyFile(REF_KEYS, 160) == KEY_UNKNOWN);
  CHECK(identifyKeyFile(NULL, 80) == KEY_UNKNOWN);

  // Rubbish with no valid type string.
  uint8_t junk[80];
  memset(junk, 0xAB, sizeof(junk));
  CHECK(identifyKeyFile(junk, 80) == KEY_UNKNOWN);
  // Type string present but not NUL-terminated within 14 bytes.
  uint8_t unterminated[80];
  memcpy(unterminated, REF_KEYS, 80);
  memset(unterminated + 16, 'x', 14);
  CHECK(identifyKeyFile(unterminated, 80) == KEY_UNKNOWN);
  // magicBytesSize > 16 is rejected (matches amiitool's load_keys).
  uint8_t bigMagic[80];
  memcpy(bigMagic, REF_KEYS, 80);
  bigMagic[31] = 17;
  CHECK(identifyKeyFile(bigMagic, 80) == KEY_UNKNOWN);

  // loadKeyPair accepts either order.
  CHECK(loadKeyPair(REF_KEYS, 80, REF_KEYS + 80, 80, &keys));
  CHECK(memcmp(&keys, REF_KEYS, 160) == 0);
  CHECK(loadKeyPair(REF_KEYS + 80, 80, REF_KEYS, 80, &keys));
  CHECK(memcmp(&keys, REF_KEYS, 160) == 0);
  // Same file twice / junk is rejected.
  CHECK(!loadKeyPair(REF_KEYS, 80, REF_KEYS, 80, &keys));
  CHECK(!loadKeyPair(REF_KEYS, 80, junk, 80, &keys));
  CHECK(keysLoaded(&keys));
}

static void testLayoutConversion() {
  uint8_t intl[kPlainSize], back[kTagSize];
  tagToInternal(REF_TAG, intl);
  memset(back, 0xCC, sizeof(back));
  internalToTag(intl, back);
  CHECK(memcmp(back, REF_TAG, 520) == 0);  // crypto region round-trips

  // Spot-check the fixed moves against the amiitool table.
  CHECK(memcmp(intl + 0x1D4, REF_TAG, 8) == 0);   // uid prefix from tag[0]
  CHECK(memcmp(intl + 0x008, REF_TAG + 0x080, 0x20) == 0);
  CHECK(memcmp(intl + 0x04C, REF_TAG + 0x0A0, 0x168) == 0);
}

static void testUnpackAgainstAmiitool() {
  AmiiboKeys keys;
  loadKeyPair(REF_KEYS, 80, REF_KEYS + 80, 80, &keys);

  uint8_t plain[kPlainSize];
  CHECK(unpack(&keys, REF_TAG, plain));
  // HMAC areas are regenerated, everything else must match the amiitool
  // internal image bit for bit.
  CHECK(memcmp(plain, REF_PLAIN, 0x008) == 0);
  CHECK(memcmp(plain + 0x028, REF_PLAIN + 0x028, 0x18C) == 0);
  CHECK(memcmp(plain + 0x1D4, REF_PLAIN + 0x1D4, 0x34) == 0);

  // A single flipped bit anywhere in the encrypted region must fail.
  uint8_t tampered[kTagSize];
  memcpy(tampered, REF_TAG, kTagSize);
  tampered[0x50] ^= 0x01;
  CHECK(!unpack(&keys, tampered, plain));
  // ...and in the stored HMAC area.
  memcpy(tampered, REF_TAG, kTagSize);
  tampered[0x90] ^= 0x80;
  CHECK(!unpack(&keys, tampered, plain));
  // Wrong keys must fail too.
  AmiiboKeys bad;
  memcpy(&bad, &keys, sizeof(bad));
  bad.data.hmacKey[0] ^= 1;
  CHECK(!unpack(&bad, REF_TAG, plain));
}

static void testPackAgainstAmiitool() {
  AmiiboKeys keys;
  loadKeyPair(REF_KEYS, 80, REF_KEYS + 80, 80, &keys);

  uint8_t tag[kTagSize];
  memset(tag, 0, sizeof(tag));
  pack(&keys, REF_PLAIN, tag);
  CHECK(memcmp(tag, REF_TAG, 520) == 0);  // matches amiitool output exactly

  // Trailer pages (130..134) are deliberately untouched by pack().
  CHECK(tag[520] == 0 && tag[539] == 0);
}

static void testResign() {
  AmiiboKeys keys;
  loadKeyPair(REF_KEYS, 80, REF_KEYS + 80, 80, &keys);

  uint8_t tag[kTagSize];
  memcpy(tag, REF_TAG, kTagSize);
  CHECK(resign(&keys, tag, TAG_RESIGNED_IDPAGES));

  // First 520 bytes: amiitool pack() of the UID-patched plain image.
  CHECK(memcmp(tag, REF_TAG_RESIGNED, 520) == 0);
  // PWD/PACK pages refreshed for the new UID (TagMo keygen).
  CHECK(memcmp(tag + 0x214, EXPECTED_PWD, 4) == 0);
  CHECK(tag[0x218] == 0x80 && tag[0x219] == 0x80 && tag[0x21A] == 0x00 && tag[0x21B] == 0x00);
  // Tag UID/BCC bytes are self-consistent.
  CHECK(tag[3] == (uint8_t)(0x88 ^ tag[0] ^ tag[1] ^ tag[2]));
  CHECK(tag[0x54] == (uint8_t)(tag[4] ^ tag[5] ^ tag[6] ^ tag[7]));

  // The re-signed dump must unpack cleanly and carry the new UID.
  uint8_t plain[kPlainSize];
  CHECK(unpack(&keys, tag, plain));
  CHECK(memcmp(plain + 0x1D4, TAG_RESIGNED_IDPAGES, 8) == 0);
  CHECK(plain[0x1DC] == (uint8_t)(TAG_RESIGNED_IDPAGES[4] ^ TAG_RESIGNED_IDPAGES[5] ^
                                   TAG_RESIGNED_IDPAGES[6] ^ TAG_RESIGNED_IDPAGES[7]));
  // plain[0] is forced from the live tag's page-2 byte 0 (TagMo patchUid).
  CHECK(plain[0] == TAG_RESIGNED_IDPAGES[8]);

  // Re-signing the already re-signed dump for the original UID restores the
  // original crypto region.
  uint8_t origUid[8];
  memcpy(origUid, REF_TAG, 8);
  CHECK(resign(&keys, tag, origUid));
  CHECK(memcmp(tag, REF_TAG, 520) == 0);

  // Garbage input is rejected, not silently signed.
  uint8_t junk[kTagSize];
  memset(junk, 0x5A, sizeof(junk));
  CHECK(!resign(&keys, junk, TAG_RESIGNED_IDPAGES));
}

int main() {
  testCryptoBackends();
  testKeyFileHandling();
  testLayoutConversion();
  testUnpackAgainstAmiitool();
  testPackAgainstAmiitool();
  testResign();
  if (failures == 0) {
    std::printf("test_amiibo_crypto: %d checks OK\n", checks);
    return 0;
  }
  std::printf("test_amiibo_crypto: %d/%d checks FAILED\n", failures, checks);
  return 1;
}
